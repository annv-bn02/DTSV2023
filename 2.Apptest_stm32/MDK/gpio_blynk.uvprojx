# Keil uVision project gpio_blynk.uvprojx, settings and files
target GPIO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gpio_blynk +hex
  AfterMake: S:\keil536\ARM\ARMCC\bin\fromelf.exe --bin Objects\gpio_blynk.axf --output Objects\gpio_blynk.bin
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8004000 size 0x10000
  memory RVCT9: RAM 0x20005000 size 0x5000
  group Source Group 1
    ../USER/: Delay.c main.c debug.c pwm.c lcd.c flash.c mcu-i2c.c sensor_pcf8574.c timer.c
  group header
    ../USER/: debug.h Delay.h lcd.h pwm.h flash.h mcu-i2c.h sensor_pcf8574.h system.h timer.h
software components: CMSIS:CORE 5.6.0, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
