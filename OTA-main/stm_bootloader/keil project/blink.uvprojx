# Keil uVision project blink.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: blink +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x2400
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User Applications
    ./: Parse.c main.c main.h
  group User Libraries
    ./: RCC_INTERFACE.c RCC_INTERFACE.h RCC_PRIVATE.h RCC_CONFIG.h GPIO_config.h GPIO_interface.h GPIO_private.h GPIO_program.c STK_config.h STK_private.h STK_program.c STK_interface.h USART_CONFIG.h USART_INTERFACE.c USART_INTERFACE.h USART_PRIVATE.h BIT_MATH.h STD_TYPES.h ESP8266_config.h ESP8266_interface.h ESP8266_private.h ESP8266_program.c FPEC_config.h FPEC_interface.h FPEC_private.h FPEC_program.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
